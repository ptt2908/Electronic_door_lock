# Keil uVision project KHOA_CUA_SO.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: KHOA_CUA_SO +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: KHOA_CUA_SO.A51
